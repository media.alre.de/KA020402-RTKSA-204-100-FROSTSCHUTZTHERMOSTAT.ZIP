Properties of the parts of a building model (IFC2X3)

# File
Description: Frostschutzthermostat, 3 m, IP40, Hysterese 1,5 K, STW, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA020402, Frostschutzthermostat, 3 m, IP40, Hysterese 1,5 K, STW, Inneneinstellung
In: Raum
Description: Die Frostschutzregler RTKSA wurden speziell zur luft- oder wasserseitigen Frostschutzsicherung von Warmwasser-Heizregistern und Wärmetauschern in Lüftungs-, Heizungs- oder Klimaanlagen entwickelt. Die Kapillare sind auf der ganzen Länge aktiv. Das Gerät spricht an, wenn die Mindestansprechlänge des Kapillars (15 cm) den eingestellten Skalenwert erreicht. Bei einem Fühlerbruch der Kontakt 1–2 dauerhaft geöffnet und der Kontakt 1–4 dauerhaft geschlossen. Ein Entriegeln nicht mehr möglich. Hinweis: Montageklammern, Tauchhülsen und Schutzwendel gehören nicht zum Lieferumfang und müssen separat bestellt werden. Luftseitige Anwendung: Für die Frostschutzsicherung von Heizregistern wird das Kapillar vor dem zu schützenden Heizregister mit Montageklammern verspannt. Hierzu sind die Montageklammern JZ-05/6M (Metall) oder JZ-05/6 K (Kunststoff) zu verwenden.; Classification: EC011174 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA020402; ModelLabel: RTKSA-204.100; GlobalTradeItemNumber: 4050528074898; ProductURL: https://alre.de/produkt_KA020402
Pset_Specification - NominalLength: 0.1468 m; NominalWidth: 0.0575 m; NominalDepth: 0.053 m; NetWeight: 0.295
Pset_ALRE_ETIM_Properties - Breite: 57.5; Höhe: 146.8; Tiefe: 53; Messbereich: 10; Explosionsgeschützt: no; Schutzart (IP): IP40; Max. Mediumtemperatur (Dauerbetrieb): 120; Länge Kapillar: 3; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 16; Schaltdifferenz einstellbar: no; ETIM-Klasse: EC011174; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA020402.pdf
